Commit message: edit urdf file and collsion checker

File: rsc/robotArm/urdf/camel_sixdof_arm.urdf (robot description, URDF)
Before this commit: robot six_dof_arm, 8 links, 7 joints
Joints:
- joint joint1: origin xyz=-0.485 -0.265 0.05 rpy=0 0 0 -> xyz=0.055 0.03 0.05 rpy=0 0 0
